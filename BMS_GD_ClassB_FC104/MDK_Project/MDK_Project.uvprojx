# Keil uVision project MDK_Project.uvprojx, settings and files
target BMS_GD_ClassB_FC104 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: BMS_GD_ClassB +hex
  AfterMake: .\crc_gen_keil.bat
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin  !L
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SOC_FAMILY_STM32,SOC_SERIES_STM32F1,USE_HAL_DRIVER,STM32F103xE,SELF_TEST,WAKE_UP
  c include: ../;../BSP;../libraries/STM32F1xx_HAL_Driver/Inc;../libraries/STM32F1xx_HAL_Driver/Inc/Legacy;../libraries/CMSIS/Device/ST/STM32F1xx/Include;../libraries/CMSIS/Include;../applications;../applications/app_task;../applications/config;../applications/driver;../rt-thread/include;../rt-thread/components/drivers/include;../rt-thread/components/drivers/include/drivers;../rt-thread/components/drivers/include/ipc;../drivers/include;../drivers/include/config;../STM32_SelfTest_Library/inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: .\ClassB_stm32F10x.sct
  group Application
    ../applications/: main.c GlobalVarShared.h
  group Application/app_task
    ../applications/app_task/: task_can1.c task_cycle.c task_led.c task_uart2.c task_control.c task_readdata.c
  group Application/app_user
    ../applications/driver/: User_Eeprom.c User_AFE_Process.c User_Soc_Func.c User_Control.c User_Relay_Mos_Control.c User_Data_process.c User_AD_Process.c User_LED.c User_Can_Process.c User_Power_Meter.c User_Balance_Process.c
  group Application/app_drivers
    ../applications/config/: config_io.c
    ../applications/driver/: bms_can.c uart_api.c bms_i2c.c bms_wakeup_sleep.c bms_ad.c m24256_i2c.c ws2812.c flash_api.c flash_api.h MCP79410.c MCP79410.h
  group libraries/STM32F1xx_HAL_Driver
    ../libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_can_legacy.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_mmc.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c
  group libraries/CMSIS
    ../libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/armcc/: system_stm32f1xx.c startup_stm32f103xe_STL.s stm32f1xx_STLcpurunKEIL.s stm32f1xx_STLcpustartKEIL.s stm32fxx_STLRamMcMxKEIL.s
  group rt-thread
    ../rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c thread.c timer.c
    ../rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../rt-thread/components/drivers/ipc/: completion.c dataqueue.c ringblk_buf.c ringbuffer.c
    ../rt-thread/components/drivers/misc/: pin.c
    ../rt-thread/components/drivers/serial/: serial.c
  group BSP
    ../BSP/: board.c stm32f1xx_hal_msp.c stm32f1xx_it.c
  group drivers
    ../drivers/: drv_adc.c drv_clk.c drv_common.c drv_eth.c drv_flash_f1.c drv_gpio.c drv_hwtimer.c drv_pwm.c drv_qspi.c drv_rtc.c drv_sdio.c drv_soft_i2c.c drv_spi.c drv_usart.c drv_usbd.c drv_usbh.c drv_wdt.c
  group STM32_SelfTest_Library
    ../STM32_SelfTest_Library/src/: stm32fxx_STLclockrun.c stm32fxx_STLclockstart.c stm32fxx_STLcrc32Run.c stm32fxx_STLmain.c stm32fxx_STLstartup.c stm32fxx_STLtranspRam.c
target No_SelfTest (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: as above
  output: BMS_GD_ClassB +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin  !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SOC_FAMILY_STM32,SOC_SERIES_STM32F1,USE_HAL_DRIVER,STM32F103xE
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target No_SelfTest_Boot (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: as above
  output: BMS_GD_ClassB +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin  !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SOC_FAMILY_STM32,SOC_SERIES_STM32F1,USE_HAL_DRIVER,STM32F103xE,USER_VECT_TAB_ADDRESS
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8005000 size 0x3b000
  memory RVCT9: RAM 0x20000000 size 0xc000
target BMS_GD_ClassB_FC104_Boot (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: as above
  output: BMS_GD_ClassB_FC104 +hex
  AfterMake: .\crc_gen_keil.bat
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin  !L
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SOC_FAMILY_STM32,SOC_SERIES_STM32F1,USE_HAL_DRIVER,STM32F103xE,SELF_TEST,USER_VECT_TAB_ADDRESS,WDI_IO
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8005000 size 0x3b000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: .\ClassB_stm32F10x_Boot.sct
